# Keil uVision project beijixiong_shaobin.uvprojx, settings and files
target beijixiong_shaobin (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: beijixiong_shaobin +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4,__FPU_USED=1U,__FPU_PRESENT=1U,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../application/typedef;../boards;../components/controller;../application/chassis;../application/other;../application/robot_cmd;../application/assist;../application/robot_param;../components/algorithm;../components/algorithm/Include;../application/VOFA;../components/support;../application/referee
  asm include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c can.c crc.c dma.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_crc.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group boards
    ../boards/: bsp_can.c bsp_can.h bsp_rc.c bsp_rc.h bsp_delay.c bsp_delay.h bsp_usart.c bsp_usart.h bsp_adc.c bsp_adc.h bsp_crc32.c bsp_crc32.h
  group controller
    ../components/controller/: pid.c pid.h
  group chassis
    ../application/chassis/: chassis_task.c chassis_task.h chassis_omni.c chassis_omni.h chassis_power_control.c chassis_power_control.h
  group other
    ../application/other/: remote_control.c remote_control.h voltage_task.c voltage_task.h
  group robot_cmd
    ../application/robot_cmd/: CAN_cmd_damiao.c CAN_cmd_damiao.h CAN_cmd_dji.c CAN_cmd_dji.h CAN_receive.c CAN_receive.h motor.c motor.h SupCap.c SupCap.h CAN_communication.c CAN_communication.h
  group assist
    ../application/assist/: detect_task.c detect_task.h
  group algorithm
    ../components/algorithm/: arm_cortexM4lf_math.lib user_lib.c
  group VOFA
    ../application/VOFA/: VOFA.c VOFA.h
  group support
    ../components/support/: CRC8_CRC16.c CRC8_CRC16.h fifo.c fifo.h
  group referee
    ../application/referee/: protocol.h referee.c referee.h referee_usart_task.c referee_usart_task.h
software components: CMSIS:CORE 4.3.0
